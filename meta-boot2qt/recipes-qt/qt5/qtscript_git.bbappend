EXTRA_QMAKEVARS_PRE_append_arm = " CONFIG-=ltcg"
