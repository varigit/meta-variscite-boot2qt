SRC_URI += " file://0001_hardware_variant_low.patch "
COMPATIBLE_MACHINE = ".*imx6.*"
