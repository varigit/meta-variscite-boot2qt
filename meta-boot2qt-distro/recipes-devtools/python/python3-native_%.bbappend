SRC_URI_remove = "file://python-3.3-multilib.patch"
