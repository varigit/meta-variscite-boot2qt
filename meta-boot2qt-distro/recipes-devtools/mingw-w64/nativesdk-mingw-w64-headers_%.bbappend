EXTRA_OECONF += "--with-default-msvcrt=ucrt"
