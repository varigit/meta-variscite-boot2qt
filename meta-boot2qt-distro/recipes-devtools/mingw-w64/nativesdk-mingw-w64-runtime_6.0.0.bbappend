EXTRA_OECONF_x86-64 = "--disable-lib32"
