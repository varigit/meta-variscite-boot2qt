EXTRA_OECONF:x86-64 = "--disable-lib32"
