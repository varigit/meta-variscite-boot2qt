FILESEXTRAPATHS_append := ":${THISDIR}/patches"
SRC_URI += "\
    file://0001-Fix-infinite-loop-when-walking-up-the-directory-hier.patch \
"
