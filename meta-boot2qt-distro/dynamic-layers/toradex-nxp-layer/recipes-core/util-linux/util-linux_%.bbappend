SRC_URI:append = " file://fstrim.service file://fstrim.timer"
