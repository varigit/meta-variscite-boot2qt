RDEPENDS:${PN}:remove:tegra = " gcc-8-cross-canadian-${TRANSLATED_TARGET_ARCH}"
